# Keil uVision project Template.uvprojx, settings and files
target Template (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD;..\HARDWARE\gprs;..\HARDWARE\OLED;..\HARDWARE\usart2;..\HARDWARE\DHT11;..\HARDWARE\dev;..\HARDWARE\DS18B20;..\HARDWARE\DPT;..\HARDWARE\ANO;..\HARDWARE\mpu6050;..\HARDWARE\I2C;..\HARDWARE\GeneralTIM;..\HARDWARE\datahandle;..\HARDWARE\adc;..\dsp_lib;..\HARDWARE\fft
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/ANO/: ano_dt.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/I2C/: bsp_i2c.c
    ../HARDWARE/GeneralTIM/: bsp_GeneralTIM.c
    ../HARDWARE/datahandle/: data_handle.c
    ../HARDWARE/adc/: bsp_adc.c
    ../HARDWARE/fft/: fft.c
  group dsp_lib
    ../dsp_lib/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
  group README
    ../: README.TXT
